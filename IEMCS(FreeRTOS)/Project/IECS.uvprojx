# Keil uVision project IECS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IECS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,
  c include: ..\User;..\User\Hardware\inc;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\Libraries\STM32F1xx_HAL_Driver\Inc\Legacy;..\Libraries\CMSIS;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\User\tuya_sdk;..\User\FreeRTOS\Source\include;..\User\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\User\FreeRTOS\Source\CMSIS_RTOS_V2;..\User\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ./: startup_stm32f103xb.s
  group CMSIS
    ../User/: system_stm32f1xx.c
  group STM32F1XX_HAL
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
  group USER
    ../User/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c GUITask.c IEMCS.h freertos.c FreeRTOSConfig.h
  group USER/HARDWARE
    ../User/Hardware/src/: LED.c usart.c oled.c i2c.c tim.c sht30.c OPT3001.c key.c dma.c rtc.c adc.c IO_device.c EEPROM.c
  group GUI
    ../User/GUI/: ASCII_6_12.c GB2312_12_12.c GUI.c
  group USER/tuya
    ../User/tuya_sdk/: mcu_api.c protocol.c system.c
  group FreeRTOS
    ../User/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../User/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../User/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../User/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
software components: CMSIS:CORE 5.4.0
